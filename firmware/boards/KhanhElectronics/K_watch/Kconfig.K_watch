## firmware/boards/KhanhElectronics/K_watch/board.yml
```yaml
board:
  name: K_watch
  full_name: K_watch by KhanhElectronics
  vendor: KhanhElectronics
  socs:
    - name: nrf52840
```
